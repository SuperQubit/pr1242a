# Keil uVision project RF_Apps.uvproj, settings and files
target RF_Apps (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RF_Control +hex
  c flags: OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, NDEBUG,STM32F10X_HD
  c misc: --c99
  c include: ..\inc;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM3210B_EVAL;..\..\..\Libraries\freemodbus\include;..\..\..\Libraries\freemodbus\ascii;..\..\..\Libraries\freemodbus\functions;..\..\..\Libraries\freemodbus\rtu;..\src\port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../src/: main.c control.c diag.c logic.c supervisor.c parser.c control_hpth.c
    ./RF_Control_Flash/: HTPBSP.lib
  group HAL
    ../src/hal/: stm32f10x_it.c
