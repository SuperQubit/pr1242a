# Keil uVision project RF_Control.uvproj, settings and files
target RF_Library (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: HTPBSP +hex (library)
  c flags: OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, NDEBUG,STM32F10X_HD
  c misc: --c99
  c include: ..\inc;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM3210B_EVAL;..\..\..\Libraries\freemodbus\include;..\..\..\Libraries\freemodbus\ascii;..\..\..\Libraries\freemodbus\functions;..\..\..\Libraries\freemodbus\rtu;..\src\port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../src/: main.c control.c diag.c logic.c supervisor.c parser.c control_hpth.c htp_msgbox.c
    ./RF_Control_Flash/: HTPBSP.lib
  group STM32F10x_StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_i2c.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_usart.c stm32f10x_iwdg.c
  group MDK-ARM
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_md.s startup_stm32f10x_xl.s
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32L1xx/startup/arm/: startup_stm32l1xx_md.s
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../src/: system_stm32f10x.c
  group HAL
    ../src/hal/: stm32f10x_it.c ds1086.c spi1.c adc.c i2c1.c spi2.c ClkGen.c hal.c tim4_pwm.c uart.c
  group BSP
    ../src/bsp/: dds.c bias.c slow_adc.c fast_adc.c supply.c com.c
target RF_Simulation (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: as above
  output: RF_Control +hex
  c flags: OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, NDEBUG,STM32F10X_HD
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target RF_Apps (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: as above
  output: RF_Control +hex
  c flags: OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, NDEBUG,STM32F10X_HD
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target RF_Control (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: as above
  output: RF_Control +hex
  c flags: OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, NDEBUG,STM32F10X_HD
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
